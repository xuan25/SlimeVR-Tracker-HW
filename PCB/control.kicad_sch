File: PCB/control.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: Migrate KiCad to version 8.0
Parts:
- renumbered C3 to C1, C3 to C10, R1 to R20
